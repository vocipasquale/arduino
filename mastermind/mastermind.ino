#include <Adafruit_NeoPixel.h>
#include <LiquidCrystal.h>


//#ifdef __AVR__
//  #include <avr/power.h>
//#endif

#define PIN 7
#define NUM_LEDS 40
#define RIGHE 10
#define COLONNE 4

Adafruit_NeoPixel strip = Adafruit_NeoPixel(NUM_LEDS, PIN, NEO_GRB + NEO_KHZ800);

const int rs=12, en=11, d4=5, d5=4, d6=3, d7=2;
LiquidCrystal display(rs, en, d4, d5, d6, d7);

int matrixLed[RIGHE][COLONNE] {
  {0,19,20,39},
  {1,18,21,38},
  {2,17,22,37},  
  {3,16,23,36},
  {4,15,24,35},
  {5,14,25,34},
  {6,13,26,33},
  {7,12,27,32},
  {8,11,28,31},
  {9,10,29,30} 
};

/*
int matrixLed[RIGHE][COLONNE] {
  {0,10,20,30},
  {1,11,21,31},
  {2,12,22,32},  
  {3,13,23,33},
  {4,14,24,34},
  {5,15,25,35},
  {6,16,26,36},
  {7,17,27,37},
  {8,18,28,38},
  {9,19,29,39} 
};
*/

const int ROSSO = 1;
const int VERDE = 2;
const int BLU = 3;
const int GIALLO = 4;
const int AZZURRO = 5;
const int BIANCO = 6;

const int btnRosso = A0;
const int btnVerde = A1;
const int btnblu = A2;
const int btnGiallo = A3;
const int btnAzzurro = A4;
const int lumin = A5;

int combinazioneSegreta[4] = {0,0,0,0};
int combinazione[4] = {-1,-1,-1,-1};

unsigned long preMillis = 0;
int rigaCorrente = 0;
int colonnaCorrente = 0;
int coloriScelti = 0;
int posizioniCorrette = 0;
int coloriCorretti = 0;
int valMax = 50;


void setup()
{
  Serial.begin(9600);
  pinMode(PIN, OUTPUT);
  pinMode(btnRosso, INPUT_PULLUP);
  pinMode(btnVerde, INPUT_PULLUP);
  pinMode(btnblu, INPUT_PULLUP);
  pinMode(btnGiallo, INPUT_PULLUP);
  pinMode(btnAzzurro, INPUT_PULLUP);
    
  display.begin(16, 2);
  display.print("!!!MASTERMIND!!!");
  
  strip.begin();
  clearMatrix();

for(int i=1; i<=6; i++){
  for(int r=0; r<RIGHE; r++){
  	for(int c=0; c<COLONNE; c++){
        accendiLed(matrixLed[r][c], i);
      }
    strip.show();
    delay(100); 
    } 
  }

for(int i=6; i>=1; i--){
  for(int r=0; r<RIGHE; r++){
  	for(int c=0; c<COLONNE; c++){
        accendiLed(matrixLed[r][c], i);
     }
  } 
  strip.show();
  delay(500);     
}
      
  clearMatrix();
  display.clear();
  display.setCursor(0, 0);
  display.print("Premi un tasto");
  
  while(leggiInput()<0){delay(100);} //blocco fino a quando non viene premuto un tasto!!!

  randomSeed(millis()); //per la generazione dei numeri casuali
  scegliCombinazione();
  delay(500);

  display.clear();
  display.setCursor(0, 0);

  //Serial.print("combinazione segreta: [");
  //for(int i=0; i<COLONNE; i++){
     //Serial.print(combinazioneSegreta[i] + String(" ")); 
  //}
  //Serial.println("]");
}

void loop()
{
  valMax = map(analogRead(lumin), 0, 1023, 8, 164);

  if(rigaCorrente >= RIGHE){//tutte le righe sono esaurite
    if(posizioniCorrette < COLONNE){
      display.clear();	
      display.setCursor(3, 0);
      display.write("HAI PERSO!!!");
      clearMatrix();
      mostraCombinazione();
      posizioniCorrette = 0;
      coloriCorretti = 0;      	
    }
    
  }else{
    //attesa scelta colore da input
    accendiLed(matrixLed[rigaCorrente][colonnaCorrente], BIANCO);
    strip.show();
    
    display.setCursor(0,0);
    display.write("P: ");
    display.setCursor(0,1);
    display.write("C: ");
    
    int btnInput = leggiInput();
    if(btnInput > 0){
      combinazione[colonnaCorrente] = btnInput;
      
      accendiLed(matrixLed[rigaCorrente][colonnaCorrente], btnInput);
      strip.show();
      
      coloriScelti++;
      colonnaCorrente++;
    }
    
    if(coloriScelti == COLONNE){
      controllaCombinazione(rigaCorrente);
      
      if(posizioniCorrette == COLONNE){
        display.clear();
        display.setCursor(3, 0);
        display.write("HAI VINTO!!!");
        rigaCorrente = 99;
      }else {
        display.setCursor(rigaCorrente+3,0); //"P: "
        char p = posizioniCorrette + '0';
        display.write(p);
        display.setCursor(rigaCorrente+3,1); //"C: "
        char c = coloriCorretti + '0';
        display.write(c);
        combinazione[0] = -1;
        combinazione[1] = -1;
        combinazione[2] = -1;
        combinazione[3] = -1;
        
        coloriCorretti = 0;
        posizioniCorrette = 0;
        coloriScelti = 0;
        rigaCorrente++;
        colonnaCorrente = 0;
      }
    }    
  }
     
  delay(400);

}


void controllaCombinazione(int riga){
  int coloriDaControllare[COLONNE] = {-1,-1,-1,-1};
  int combinazioneSegretaSingoli[COLONNE] = {-9,-9,-9,-9};
  int indUltimoColore = 0;
  int indUltimoSingolo = 0;
  
  //controllo posizioni ("neri")
  for(int i=0; i<COLONNE; i++){
    if(combinazione[i] == combinazioneSegreta[i]){
      posizioniCorrette++;      
    }else{
      //se non è nella posizione corretta,inserisco l'input corrente  
      //in un array temporaneo per controllare i colori successivamente ("bianchi")
      //..ma solo se non l'ho già messo da parte prima
      if(!contiene(coloriDaControllare, COLONNE, combinazione[i])){
      	coloriDaControllare[indUltimoColore]=combinazione[i];
      	indUltimoColore++;      }
      
          
      //inserisco il colore della combinazione segreta
      //in un array temporaneo che contiene i colori non ripetuti
      if(!contiene(combinazioneSegretaSingoli, COLONNE, combinazioneSegreta[i])){
      	combinazioneSegretaSingoli[indUltimoSingolo]=combinazioneSegreta[i];
        indUltimoSingolo++;
      }
           
    }
    
    /*
    Serial.print("colori da controllare: [");
    for(int i=0; i<COLONNE; i++){
       Serial.print(coloriDaControllare[i] + String(" ")); 
    }
    Serial.println("]");
    
    Serial.print("combinazione segreta singoli: [");
    for(int i=0; i<COLONNE; i++){
       Serial.print(combinazioneSegretaSingoli[i] + String(" ")); 
    }
    Serial.println("]");
    */
    
  } 
  
    
  //controllo colori
  for(int i=0; i<COLONNE; i++){
  	for(int c=0; c<COLONNE; c++){
      if(coloriDaControllare[i]==combinazioneSegretaSingoli[c]){
      		coloriCorretti++;
      }   
    }
  }
 
  
}

boolean contiene(int arr[], int length, int v) {
  for (int i = 0; i < length; i++) {
    if (arr[i] == v) {
      return true;
    }
  }
  return false;
}


void clearMatrix(){
  //SPENTO
  	for(int r=0; r<RIGHE; r++){
    	for(int c=0; c<COLONNE; c++){
      		accendiLed(matrixLed[r][c], 9);
    	}
  	}
    strip.show();  
}

void scegliCombinazione(){
 // 1 --> ROSSO
 // 2 --> VERDE
 // 3 --> BLU
 // 4 --> GIALLO 
 // 5 --> AZZURRO  
 combinazioneSegreta[0] = random(1, 6);
 combinazioneSegreta[1] = random(1, 6);
 combinazioneSegreta[2] = random(1, 6);
 combinazioneSegreta[3] = random(1, 6);
  
}


uint32_t getColor(int c) {
  switch (c) {
    case 1:
    	return strip.Color(valMax, 0, 0); // ROSSO
    case 2:
    	return strip.Color(0, valMax, 0); // VERDE
    case 3:
    	return strip.Color(0, 0, valMax); // BLU
    case 4:
    	return strip.Color(valMax, valMax, 0); // GIALLO
    case 5:
    	return strip.Color(valMax/3, valMax/3, valMax); // AZZURRO
    case 6:
    	return strip.Color(valMax, valMax, valMax); // BIANCO
    default:
    	return strip.Color(0, 0, 0); // Off
  }
}


void mostraCombinazione(){
	accendiLed(matrixLed[0][0], combinazioneSegreta[0]);
  	accendiLed(matrixLed[0][1], combinazioneSegreta[1]);
	accendiLed(matrixLed[0][2], combinazioneSegreta[2]);
	accendiLed(matrixLed[0][3], combinazioneSegreta[3]);
  	
  	strip.show();
}

void accendiLed(int pinLed, int color){
  strip.setPixelColor(pinLed, getColor(color));	  
}

int leggiInput(){
 
  if(digitalRead(btnRosso) == LOW){
    return ROSSO;
  }
  
  if(digitalRead(btnVerde) == LOW){
    return VERDE;
  }
  
  if(digitalRead(btnblu) == LOW){
    return BLU;
  }
  
  if(digitalRead(btnGiallo) == LOW){
    return GIALLO;
  }
  
  if(digitalRead(btnAzzurro) == LOW){
    return AZZURRO;
  }
  
  return -1;
}
